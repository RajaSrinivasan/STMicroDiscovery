# Keil uVision project adc.uvprojx, settings and files
target adc (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: adc
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ../Inc;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Inc;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_adc.c stm32f0xx_hal_crc_ex.c
  group Application/User
    ../Src/: crc.c adc.c freertos.c stm32f0xx_hal_timebase_TIM.c main.c stm32f0xx_it.c stm32f0xx_hal_msp.c gpio.c adctasks.c
  group Drivers/CMSIS
    C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Middlewares/FreeRTOS
    C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c croutine.c
    C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/rsrinivasan/STM32Cube/Repository/STM32Cube_FW_F0_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 4.1.0
